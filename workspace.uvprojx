# Keil uVision project workspace.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: .\CMISS;.\FWLIB\inc;.\USER;.\DEVICE;.\USER\delay;.\USER\sys;.\USERLIB;.\HARDWARE;.\DEVICE\CAN\CAN1;.\DEVICE\LED;.\DEVICE\TIMER\TIMER3;.\DEVICE\USART\USART1;.\DEVICE\USART\USART3;.\DEVICE\USART\USART6;.\HARDWARE\CHASSIS;.\HARDWARE\CONTROL_TASK;.\HARDWARE\GIMBAL;.\HARDWARE\JUDGEMENT_SYSTEM;.\HARDWARE\REMOTER;.\USERLIB\DJ_PROTOCOL;.\USERLIB\LISTENER;.\USERLIB\PID;.\HARDWARE\SHOOTER;.\DEVICE\PWM
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c control.h
    ./USER/delay/: delay.c
    ./USER/sys/: sys.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMISS
    ./CMISS/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f427xx.s stm32f4xx_it.c system_stm32f4xx.c
  group DEVICE
    ./DEVICE/LED/: led.c
    ./DEVICE/CAN/CAN1/: can1.c
    ./DEVICE/TIMER/TIMER3/: timer3.c
    ./DEVICE/USART/USART1/: usart1.c
    ./DEVICE/USART/USART3/: usart3.c
    ./DEVICE/USART/USART6/: usart6.c
    ./DEVICE/PWM/: pwm.c
  group USERLIB
    ./HARDWARE/REMOTER/: remoter.c
    ./USERLIB/DJ_PROTOCOL/: DJ_Protocol.c
    ./USERLIB/LISTENER/: listener.c
    ./USERLIB/PID/: pid.c
  group HARDWARE
    ./HARDWARE/CHASSIS/: chassis.c
    ./HARDWARE/CONTROL_TASK/: control_task.c
    ./HARDWARE/GIMBAL/: gimbal.c
    ./HARDWARE/JUDGEMENT_SYSTEM/: judge_system.c
    ./HARDWARE/SHOOTER/: shooter.c
